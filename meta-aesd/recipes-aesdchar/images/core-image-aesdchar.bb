inherit core-image
CORE_IMAGE_EXTRA_INSTALL += "aesdchar"
CORE_IMAGE_EXTRA_INSTALL += "openssh"
